# Keil uVision project TURN_STM32F4_V001-A.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TURN_STM32F4_V001-A +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__FPU_PRESENT=1,__FPU_USED =1,RSI_SPI_INTERFACE,RSI_WLAN_ENABLE,RSI_WITH_OS,RSI_WAC_MFI_ENABLE
  c misc: --diag_suppress=1 --diag_suppress=1035
  c include: ..\..\library\STM32F4xx_StdPeriph_Driver\inc;..\..\library\CMSIS;..\..\library\CMSIS\Include;..\..\ucosii\uC-CPU;..\..\ucosii\uC-CPU\ARM-Cortex-M4\RealView;..\..\ucosii\uC-LIB;..\..\ucosii\uCOS-II\Source;..\..\ucosii\uCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;..\..\usr;..\..\usr\include;..\..\usr\bsp\inc;..\..\usr\include\motion_ctrl;..\..\usr\common\fatfs\src;..\..\usr\rs9113_wifi\sapis\include;..\..\usr\bsp;..\..\usr\common\minIni;..\..\usr\include\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Cmsis
    ../../library/CMSIS/: system_stm32f4xx.c startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ../../library/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group uc/cpu
    ../../ucosii/uC-CPU/: cpu_core.c
    ../../ucosii/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group uc/lib
    ../../ucosii/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../ucosii/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group uc/os-ii/source
    ../../ucosii/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uc/os-ii/port
    ../../ucosii/uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group user
    ../../usr/bsp/: bsp.c
    ../../usr/: stm32f4xx_it.c
    ../../usr/application/: main.c agvcp.c root.c agv.c motion_ctrl.c can_dispatcher.c Navigation.c motors.c encoder.c bms.c test.c console.c configuration.c algorithm.c
    ../../usr/application/motion_ctrl/: Rotating.c MCTools.c VPlan.c DataBank.c rAGVControl.c reverseMotionControl.c fuzzyhuo.c Tracingzq.c TshapeVplan.c angle.c MotionEstimate.c
    ../../usr/bsp/src/: bsp_can.c
  group bsp
    ../../usr/bsp/src/: bsp_uart.c bsp_led.c bsp_io.c bsp_pwm.c bsp_encoder.c bsp_sdio_sd.c bsp_timer.c
  group FATFS
    ../../usr/common/fatfs/src/: diskio.c ff.c
    ../../usr/common/fatfs/src/option/: syscall.c unicode.c
  group RS9113
    ../../usr/rs9113_wifi/: wifi.c
    ../../usr/rs9113_wifi/sapis/common/: rsi_common_apis.c rsi_device_init_apis.c
    ../../usr/rs9113_wifi/sapis/driver/: rsi_bt_ble.c rsi_common.c rsi_device_init.c rsi_driver.c rsi_driver_event_handlers.c rsi_events.c rsi_iap.c rsi_nwk.c rsi_os_none.c rsi_pkt_mgmt.c rsi_queue.c rsi_scheduler.c rsi_setregion_countryinfo.c rsi_timer.c rsi_utils.c rsi_wlan.c rsi_zb.c rsi_zb_utility.c
    ../../usr/rs9113_wifi/sapis/driver/intf/spi/: rsi_spi_frame_rd_wr.c rsi_spi_functs.c rsi_spi_iface_init.c rsi_spi_mem_rd_wr.c rsi_spi_reg_rd_wr.c
    ../../usr/rs9113_wifi/sapis/hal/: rsi_hal_mcu_interrupt.c rsi_hal_mcu_ioports.c rsi_hal_mcu_random.c rsi_hal_mcu_spi.c rsi_hal_mcu_timer.c rsi_hal_mcu_uart.c
    ../../usr/rs9113_wifi/sapis/nwk/socket/: rsi_socket.c
    ../../usr/rs9113_wifi/sapis/os/ucosii/: rsi_os_wrapper.c
    ../../usr/rs9113_wifi/sapis/wlan/: rsi_wlan_apis.c
    ../../usr/rs9113_wifi/sapis/nwk/applications/http_server/: rsi_json_handlers.c
    ../../usr/rs9113_wifi/sapis/driver/intf/: rsi_intf_lock.c
  group common
    ../../usr/common/: log_print.c lwshell.c tools.c sliding_filter.c
    ../../usr/common/minIni/: minIni.c
